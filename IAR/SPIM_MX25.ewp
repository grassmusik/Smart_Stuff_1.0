# IAR project SPIM_MX25.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR_SPIX_PRAGMA; IAR_PRAGMAS; TARGET=MAX3263x; BOARD=EvKit_V1; TARGET_REV=0x4132; MXC_ADC_REV=0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe826
  ICCARM.CCIncludePath2: ..; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: SPIM_MX25.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group (top)
    ../ARM/: Abstract.txt
    ../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/BSP Board Support
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Boards/Maxim/MAX32630_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Boards/Maxim/MAX32630_EVKIT/Common/Source/: led.c max14690.c mx25.c nhd12832.c pb.c stdio.c
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Documents/: MAX32630_EVKIT_Datasheet.pdf
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#4.3.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Communications I2C Master
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: i2cm.c
  group CMSIS-Pack/Communications SPI Master
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: spim.c
  group CMSIS-Pack/Communications UART
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: uart.c
  group CMSIS-Pack/Device Startup
    RTE/MAX32630/Maxim/: cmain.s low_level_init.c max3263x.h startup_max3263x.s system_max3263x.c
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: nvic_table.c
  group CMSIS-Pack/HAL Hardware Access Layer
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: clkman.c flc.c icc.c lp.c mxc_assert.c mxc_lock.c mxc_sys.c
    RTE/MAX32630/Maxim/: mxc_config.h
  group CMSIS-Pack/Peripherals GPIO
    ${CMSIS_PACK_PATH_Maxim#MAX32630#0.2.7-a}$/Libraries/MAX3263XPeriphDriver/Source/: gpio.c ioman.c
